// Minimal SSD1306 / SH1106 128x64 I2C OLED driver with a 5x7 font.
#include <string.h>
#include <stdio.h>
#include <stdarg.h>
#include "driver/i2c_master.h"
#include "esp_log.h"
#include "esp_timer.h"
#include "sdkconfig.h"
#include "display.h"

static const char *TAG = "disp";
static i2c_master_bus_handle_t s_bus;
static i2c_master_dev_handle_t s_dev;
static uint8_t s_fb[DISP_W * DISP_H / 8];
static bool s_ok, s_bus_ok;
static uint32_t s_last_probe;

// Classic 5x7 font, ASCII 0x20..0x7E, one byte per column, LSB = top row.
static const uint8_t FONT[95][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x08,0x07,0x03,0x00},
    {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x2A,0x1C,0x7F,0x1C,0x2A},{0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x80,0x70,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4D,0x33},
    {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
    {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1E},{0x00,0x00,0x14,0x00,0x00},{0x00,0x40,0x34,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},
    {0x3E,0x41,0x5D,0x59,0x4E},{0x7C,0x12,0x11,0x12,0x7C},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x41,0x3E},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x41,0x51,0x73},
    {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x1C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x26,0x49,0x49,0x49,0x32},
    {0x03,0x01,0x7F,0x01,0x03},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4D,0x43},{0x00,0x7F,0x41,0x41,0x41},
    {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x41,0x7F},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
    {0x00,0x03,0x07,0x08,0x00},{0x20,0x54,0x54,0x78,0x40},{0x7F,0x28,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x28},
    {0x38,0x44,0x44,0x28,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x00,0x08,0x7E,0x09,0x02},{0x18,0xA4,0xA4,0x9C,0x78},
    {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x40,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x78,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0xFC,0x18,0x24,0x24,0x18},{0x18,0x24,0x24,0x18,0xFC},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x24},
    {0x04,0x04,0x3F,0x44,0x24},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
    {0x44,0x28,0x10,0x28,0x44},{0x4C,0x90,0x90,0x90,0x7C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x77,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x02,0x01,0x02,0x04,0x02},
};

static esp_err_t cmd(const uint8_t *c, size_t n)
{
    uint8_t buf[32];
    buf[0] = 0x00;
    memcpy(buf + 1, c, n);
    return i2c_master_transmit(s_dev, buf, n + 1, 100);
}

static const uint8_t INIT_SEQ[] = {
    0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40, 0x8D, 0x14,
    0x20, 0x00, 0xA1, 0xC8, 0xDA, 0x12, 0x81, 0xCF, 0xD9, 0xF1,
    0xDB, 0x40, 0xA4, 0xA6, 0x2E, 0xAF,
};

// Look for the display; safe to call any time (hot-plug).
static bool probe(void)
{
    s_last_probe = (uint32_t)(esp_timer_get_time() / 1000);
    if (!s_bus_ok) return false;
    if (i2c_master_probe(s_bus, CONFIG_OLED_ADDR, 30) != ESP_OK) return false;
    return cmd(INIT_SEQ, sizeof(INIT_SEQ)) == ESP_OK;
}

bool disp_present(void) { return s_ok; }

bool disp_init(void)
{
    if (CONFIG_PIN_I2C_SDA < 0 || CONFIG_PIN_I2C_SCL < 0) return false;
    i2c_master_bus_config_t bc = {
        .i2c_port = I2C_NUM_0,
        .sda_io_num = CONFIG_PIN_I2C_SDA,
        .scl_io_num = CONFIG_PIN_I2C_SCL,
        .clk_source = I2C_CLK_SRC_DEFAULT,
        .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };
    if (i2c_new_master_bus(&bc, &s_bus) != ESP_OK) return false;
    i2c_device_config_t dc = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7,
        .device_address = CONFIG_OLED_ADDR,
        .scl_speed_hz = 400000,
    };
    if (i2c_master_bus_add_device(s_bus, &dc, &s_dev) != ESP_OK) return false;
    s_bus_ok = true;                         // only now is s_dev valid (probe() uses it)

    s_ok = probe();
    if (!s_ok) ESP_LOGW(TAG, "no OLED at 0x%02X - running without screen", CONFIG_OLED_ADDR);
    disp_clear();
    disp_flush();
    return s_ok;
}

void disp_contrast(uint8_t level) { uint8_t c[] = {0x81, level}; if (s_ok) cmd(c, 2); }
void disp_invert(bool on) { uint8_t c = on ? 0xA7 : 0xA6; if (s_ok) cmd(&c, 1); }
void disp_power(bool on) { uint8_t c = on ? 0xAF : 0xAE; if (s_ok) cmd(&c, 1); }

void disp_flush(void)
{
    if (!s_ok) {                                  // plugged in later? check every 3 s
        if ((uint32_t)(esp_timer_get_time() / 1000) - s_last_probe < 3000 || !probe()) return;
        s_ok = true;
        ESP_LOGI(TAG, "OLED connected");
    }
    esp_err_t err = ESP_OK;
    static uint8_t buf[DISP_W + 1];
    buf[0] = 0x40;
#if CONFIG_OLED_SH1106
    for (int p = 0; p < 8; p++) {
        uint8_t c[] = {(uint8_t)(0xB0 + p), 0x02, 0x10};   // SH1106 RAM is 132 wide, offset 2
        cmd(c, 3);
        memcpy(buf + 1, s_fb + p * DISP_W, DISP_W);
        err |= i2c_master_transmit(s_dev, buf, DISP_W + 1, 100);
    }
#else
    static const uint8_t win[] = {0x21, 0, 127, 0x22, 0, 7};
    cmd(win, sizeof(win));
    for (int p = 0; p < 8; p++) {
        memcpy(buf + 1, s_fb + p * DISP_W, DISP_W);
        err |= i2c_master_transmit(s_dev, buf, DISP_W + 1, 100);
    }
#endif
    if (err != ESP_OK) { s_ok = false; ESP_LOGW(TAG, "OLED disconnected"); }
}

void disp_clear(void) { memset(s_fb, 0, sizeof(s_fb)); }

void disp_pixel(int x, int y, bool on)
{
    if (x < 0 || y < 0 || x >= DISP_W || y >= DISP_H) return;
    uint8_t *b = &s_fb[(y >> 3) * DISP_W + x];
    if (on) *b |= 1 << (y & 7); else *b &= ~(1 << (y & 7));
}

void disp_fill_rect(int x, int y, int w, int h, bool on)
{
    for (int j = y; j < y + h; j++)
        for (int i = x; i < x + w; i++) disp_pixel(i, j, on);
}

void disp_hline(int x, int y, int w) { for (int i = 0; i < w; i++) disp_pixel(x + i, y, true); }

void disp_rect(int x, int y, int w, int h)
{
    disp_hline(x, y, w);
    disp_hline(x, y + h - 1, w);
    for (int j = y; j < y + h; j++) { disp_pixel(x, j, true); disp_pixel(x + w - 1, j, true); }
}

static void glyph(int x, int y, char ch, bool inv, int scale)
{
    if (ch < 0x20 || ch > 0x7E) ch = '?';
    const uint8_t *g = FONT[ch - 0x20];
    for (int col = 0; col < 6; col++) {
        uint8_t bits = col < 5 ? g[col] : 0;
        for (int row = 0; row < 8; row++) {
            bool on = ((bits >> row) & 1) ^ inv;
            for (int sy = 0; sy < scale; sy++)
                for (int sx = 0; sx < scale; sx++)
                    disp_pixel(x + col * scale + sx, y + row * scale + sy, on);
        }
    }
}

int disp_text(int x, int y, const char *s, bool invert)
{
    for (; *s && x < DISP_W; s++, x += CHAR_W) glyph(x, y, *s, invert, 1);
    return x;
}

int disp_text_big(int x, int y, const char *s)
{
    for (; *s && x < DISP_W; s++, x += CHAR_W * 2) glyph(x, y, *s, false, 2);
    return x;
}

int disp_printf(int x, int y, bool invert, const char *fmt, ...)
{
    char buf[64];
    va_list ap;
    va_start(ap, fmt);
    vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    return disp_text(x, y, buf, invert);
}
